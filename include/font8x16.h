#ifndef FONT8X16_H
#define FONT8X16_H

#include <stdint.h>
#include <wchar.h>

#define ARRAY_LENGHT 36


/*
    
    !!! ОБДУМАТЬ !!!
    Возможно перевести хранимые символы в структуру
    
    */
typedef struct font_symbol {
    wchar_t c;
    uint8_t bits[5];
} font_symbol;

static const font_symbol font_5x7[ARRAY_LENGHT] = {
    {L' ', { 0x00, 0x00, 0x00, 0x00, 0x00 }},       // Пробел
    {L'%', { 0x23, 0x13, 0x08, 0x64, 0x62 }},       // %
    {L'\'', { 0x00, 0x07, 0x05, 0x07, 0x00 }},      // ' (апостроф для градуса)
    {L'*', { 0xc6, 0x6c, 0x3f, 0x6c, 0xc6 }},       // *
    {L'-', { 0x08, 0x08, 0x08, 0x08, 0x08 }},       // - (минус)
    {L'.', { 0x00, 0x60, 0x60, 0x00, 0x00 }},       // . (точка)
    {L'0', { 0x3e, 0x51, 0x49, 0x45, 0x3e }},       // 0
    {L'1', { 0x00, 0x42, 0x7f, 0x40, 0x00 }},       // 1
    {L'2', { 0x42, 0x61, 0x51, 0x49, 0x46 }},       // 2
    {L'3', { 0x21, 0x41, 0x45, 0x4b, 0x31 }},       // 3
    {L'4', { 0x18, 0x14, 0x12, 0x7f, 0x10 }},       // 4
    {L'5', { 0x27, 0x45, 0x45, 0x45, 0x39 }},       // 5
    {L'6', { 0x3c, 0x4a, 0x49, 0x49, 0x30 }},       // 6
    {L'7', { 0x01, 0x71, 0x09, 0x05, 0x03 }},       // 7
    {L'8', { 0x36, 0x49, 0x49, 0x49, 0x36 }},       // 8
    {L'9', { 0x06, 0x49, 0x49, 0x29, 0x1e }},       // 9
    {L':', { 0x00, 0x36, 0x36, 0x00, 0x00 }},       // : (двоеточие)
    {L'>', { 0x81, 0xc3, 0x66, 0x3c, 0x18 }},       // > (знак больше)
    {L'а', { 0xf0, 0x2e, 0x21, 0x2e, 0xf0 }},       // а
    {L'в', { 0xff, 0x89, 0x89, 0x96, 0x60 }},       // в
    {L'е', { 0xff, 0x89, 0x89, 0x81, 0x80 }},       // е
    {L'ж', { 0xff, 0x10, 0x78, 0x10, 0xff }},       // ж
    {L'з', { 0x80, 0x81, 0x89, 0x89, 0xf7 }},       // з
    {L'и', { 0xff, 0x60, 0x18, 0x06, 0xff }},       // и
    {L'л', { 0x80, 0x7e, 0x01, 0x01, 0xfe }},       // л
    {L'м', { 0xff, 0x06, 0x18, 0x06, 0xff }},       // м
    {L'н', { 0xff, 0x08, 0x08, 0x08, 0xff }},       // н
    {L'о', { 0x7e, 0x81, 0x81, 0x81, 0x7e }},       // о
    {L'п', { 0xff, 0x01, 0x01, 0x01, 0xff }},       // п
    {L'р', { 0xff, 0x09, 0x09, 0x09, 0x06 }},       // р
    {L'с', { 0x7e, 0x81, 0x81, 0x81, 0x40 }},       // с
    {L'т', { 0x01, 0x01, 0xff, 0x01, 0x01 }},       // т
    {L'у', { 0x0f, 0x88, 0x88, 0x88, 0xff }},       // у
    {L'ч', { 0x0f, 0x08, 0x08, 0x08, 0xff }},       // ч
    {L'ь', { 0xff, 0x88, 0x88, 0x88, 0x70 }},       // ь
    {L'ю', { 0xff, 0x10, 0xff, 0x81, 0xff }},       // ю
};

const uint8_t* get_font_bytes_array(wchar_t c) {
    int left = 0;
    int right = ARRAY_LENGHT - 1;
    while (left <= right) {
        int mid = left + (right - left) / 2;

        if (font_5x7[mid].c == c) {
            return font_5x7[mid].bits;
        }

        if (font_5x7[mid].c < c) {
            left = mid + 1;
        } else {
            right = mid - 1;
        }
    }
    return NULL;
}

#endif
